VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO tt_gf_cartrip_lg_nameplate
  CLASS BLOCK ;
  FOREIGN tt_gf_cartrip_lg_nameplate ;
  ORIGIN 0.000 0.000 ;
  SIZE 14.000 BY 12.000 ;
  OBS
      LAYER Metal1 ;
        RECT 1.120 6.720 2.240 10.640 ;
        RECT 7.840 9.520 11.760 10.640 ;
        RECT 5.600 8.400 6.160 8.960 ;
        RECT 5.040 7.840 6.720 8.400 ;
        RECT 5.600 7.280 6.160 7.840 ;
        RECT 7.840 6.720 8.960 9.520 ;
        RECT 9.520 7.280 11.760 8.400 ;
        RECT 10.640 6.720 11.760 7.280 ;
        RECT 1.120 5.600 5.040 6.720 ;
        RECT 7.840 5.600 11.760 6.720 ;
        RECT 0.560 3.920 2.800 5.040 ;
        RECT 3.360 3.920 3.920 5.040 ;
        RECT 0.560 3.360 1.680 3.920 ;
        RECT 0.560 2.240 2.800 3.360 ;
        RECT 1.680 1.680 2.800 2.240 ;
        RECT 0.560 0.560 2.800 1.680 ;
        RECT 3.360 0.560 3.920 3.360 ;
        RECT 4.480 1.680 5.040 5.040 ;
        RECT 6.160 3.360 6.720 5.040 ;
        RECT 8.400 3.360 8.960 5.040 ;
        RECT 6.160 2.240 7.280 3.360 ;
        RECT 7.840 2.240 8.960 3.360 ;
        RECT 9.520 4.480 12.320 5.040 ;
        RECT 9.520 3.360 10.640 4.480 ;
        RECT 11.200 3.360 12.320 4.480 ;
        RECT 9.520 2.240 12.320 3.360 ;
        RECT 4.480 0.560 6.160 1.680 ;
        RECT 6.720 1.120 8.400 2.240 ;
        RECT 7.280 0.560 7.840 1.120 ;
        RECT 9.520 0.560 10.640 2.240 ;
        RECT 11.200 0.560 12.320 2.240 ;
      LAYER Metal2 ;
        RECT 1.120 6.720 2.240 10.640 ;
        RECT 7.840 9.520 11.760 10.640 ;
        RECT 5.600 8.400 6.160 8.960 ;
        RECT 5.040 7.840 6.720 8.400 ;
        RECT 5.600 7.280 6.160 7.840 ;
        RECT 7.840 6.720 8.960 9.520 ;
        RECT 9.520 7.280 11.760 8.400 ;
        RECT 10.640 6.720 11.760 7.280 ;
        RECT 1.120 5.600 5.040 6.720 ;
        RECT 7.840 5.600 11.760 6.720 ;
        RECT 0.560 3.920 2.800 5.040 ;
        RECT 3.360 3.920 3.920 5.040 ;
        RECT 0.560 3.360 1.680 3.920 ;
        RECT 0.560 2.240 2.800 3.360 ;
        RECT 1.680 1.680 2.800 2.240 ;
        RECT 0.560 0.560 2.800 1.680 ;
        RECT 3.360 0.560 3.920 3.360 ;
        RECT 4.480 1.680 5.040 5.040 ;
        RECT 6.160 3.360 6.720 5.040 ;
        RECT 8.400 3.360 8.960 5.040 ;
        RECT 6.160 2.240 7.280 3.360 ;
        RECT 7.840 2.240 8.960 3.360 ;
        RECT 9.520 4.480 12.320 5.040 ;
        RECT 9.520 3.360 10.640 4.480 ;
        RECT 11.200 3.360 12.320 4.480 ;
        RECT 9.520 2.240 12.320 3.360 ;
        RECT 4.480 0.560 6.160 1.680 ;
        RECT 6.720 1.120 8.400 2.240 ;
        RECT 7.280 0.560 7.840 1.120 ;
        RECT 9.520 0.560 10.640 2.240 ;
        RECT 11.200 0.560 12.320 2.240 ;
      LAYER Metal3 ;
        RECT 1.120 6.720 2.240 10.640 ;
        RECT 7.840 9.520 11.760 10.640 ;
        RECT 5.600 8.400 6.160 8.960 ;
        RECT 5.040 7.840 6.720 8.400 ;
        RECT 5.600 7.280 6.160 7.840 ;
        RECT 7.840 6.720 8.960 9.520 ;
        RECT 9.520 7.280 11.760 8.400 ;
        RECT 10.640 6.720 11.760 7.280 ;
        RECT 1.120 5.600 5.040 6.720 ;
        RECT 7.840 5.600 11.760 6.720 ;
        RECT 0.560 3.920 2.800 5.040 ;
        RECT 3.360 3.920 3.920 5.040 ;
        RECT 0.560 3.360 1.680 3.920 ;
        RECT 0.560 2.240 2.800 3.360 ;
        RECT 1.680 1.680 2.800 2.240 ;
        RECT 0.560 0.560 2.800 1.680 ;
        RECT 3.360 0.560 3.920 3.360 ;
        RECT 4.480 1.680 5.040 5.040 ;
        RECT 6.160 3.360 6.720 5.040 ;
        RECT 8.400 3.360 8.960 5.040 ;
        RECT 6.160 2.240 7.280 3.360 ;
        RECT 7.840 2.240 8.960 3.360 ;
        RECT 9.520 4.480 12.320 5.040 ;
        RECT 9.520 3.360 10.640 4.480 ;
        RECT 11.200 3.360 12.320 4.480 ;
        RECT 9.520 2.240 12.320 3.360 ;
        RECT 4.480 0.560 6.160 1.680 ;
        RECT 6.720 1.120 8.400 2.240 ;
        RECT 7.280 0.560 7.840 1.120 ;
        RECT 9.520 0.560 10.640 2.240 ;
        RECT 11.200 0.560 12.320 2.240 ;
      LAYER Metal4 ;
        RECT 1.120 6.720 2.240 10.640 ;
        RECT 7.840 9.520 11.760 10.640 ;
        RECT 5.600 8.400 6.160 8.960 ;
        RECT 5.040 7.840 6.720 8.400 ;
        RECT 5.600 7.280 6.160 7.840 ;
        RECT 7.840 6.720 8.960 9.520 ;
        RECT 9.520 7.280 11.760 8.400 ;
        RECT 10.640 6.720 11.760 7.280 ;
        RECT 1.120 5.600 5.040 6.720 ;
        RECT 7.840 5.600 11.760 6.720 ;
        RECT 0.560 3.920 2.800 5.040 ;
        RECT 3.360 3.920 3.920 5.040 ;
        RECT 0.560 3.360 1.680 3.920 ;
        RECT 0.560 2.240 2.800 3.360 ;
        RECT 1.680 1.680 2.800 2.240 ;
        RECT 0.560 0.560 2.800 1.680 ;
        RECT 3.360 0.560 3.920 3.360 ;
        RECT 4.480 1.680 5.040 5.040 ;
        RECT 6.160 3.360 6.720 5.040 ;
        RECT 8.400 3.360 8.960 5.040 ;
        RECT 6.160 2.240 7.280 3.360 ;
        RECT 7.840 2.240 8.960 3.360 ;
        RECT 9.520 4.480 12.320 5.040 ;
        RECT 9.520 3.360 10.640 4.480 ;
        RECT 11.200 3.360 12.320 4.480 ;
        RECT 9.520 2.240 12.320 3.360 ;
        RECT 4.480 0.560 6.160 1.680 ;
        RECT 6.720 1.120 8.400 2.240 ;
        RECT 7.280 0.560 7.840 1.120 ;
        RECT 9.520 0.560 10.640 2.240 ;
        RECT 11.200 0.560 12.320 2.240 ;
  END
END tt_gf_cartrip_lg_nameplate
END LIBRARY
